# Keil uVision project DTU.uvprojx, settings and files
target DTU (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: DTU +hex
  AfterMake: fromelf --bin --output .\DTU\DTU.bin .\DTU\DTU.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c iwdg.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Application/Bsp
    ../User/Src/: global.c flash.c serial_transceiver.c ec600.c gas_fifo.c cJSON.c temper_control.c linked_list.c temper_fifo.c topic_fifo.c rtc.c
    ../User/Inc/: rtc.h
  group Application/User
    ../User/Src/: timer.c debug.c lte_demo.c topic.c Gaspower.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_iwdg.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
target DEBUG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: as above
  output: DTU +hex
  AfterMake: fromelf --bin --output .\DTU\DTU.bin .\DTU\DTU.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx,DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0xc800
  memory RVCT9: RAM 0x20000000 size 0x9000
software components: CMSIS:CORE 4.3.0
